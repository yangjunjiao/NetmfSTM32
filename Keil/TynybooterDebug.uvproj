# Keil uVision project TynybooterDebug.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103ZG STMicroelectronics
  cpu: IRAM(0x20000000-0x20017FFF) IROM(0x8000000-0x80FFFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Tinybooter
  c flags: Optim=1
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
