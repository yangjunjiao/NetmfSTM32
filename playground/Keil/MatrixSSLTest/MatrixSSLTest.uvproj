# Keil uVision project MatrixSSLTest.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103ZG STMicroelectronics
  cpu: IRAM(0x20000000-0x20017FFF) IROM(0x8000000-0x80FFFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: lwip +hex
  c flags: Optim=1
  c include: ..\MatrixSSl\matrixssl-3-3-open
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group Source Group 1
    ./: main.c start.c stm32f10x_it.c STM32F10xR.LIB startup_stm32f10x_xl.s
    ../MatrixSSl/output/: MatrixSSlLib.lib
