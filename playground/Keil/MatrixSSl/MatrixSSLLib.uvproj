# Keil uVision project MatrixSSLLib.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103ZG STMicroelectronics
  cpu: IRAM(0x20000000-0x20017FFF) IROM(0x8000000-0x80FFFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: MatrixSSlLib +hex (library)
  c flags: Optim=1
  c include: .\matrixssl-3-3-open
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group MatrixSSL_Crypto
    ./matrixssl-3-3-open/crypto/digest/: hmac.c md5.c sha1.c
    ./matrixssl-3-3-open/crypto/keyformat/: asn1.c base64.c x509.c
    ./matrixssl-3-3-open/crypto/math/: pstm.c
    ./matrixssl-3-3-open/crypto/prng/: prng.c yarrow.c
    ./matrixssl-3-3-open/crypto/pubkey/: pkcs.c pubkey.c rsa.c
    ./matrixssl-3-3-open/crypto/symmetric/: aes.c arc4.c des3.c rc2.c
  group MatrixSSL_Core
    ./matrixssl-3-3-open/core/noOs/: noOs.c
  group matrixSSL
    ./matrixssl-3-3-open/matrixssl/: cipherSuite.c matrixssl.c matrixsslApi.c matrixsslApi.h matrixsslConfig.h matrixssllib.h sslDecode.c sslEncode.c sslv3.c tls.c version.h
