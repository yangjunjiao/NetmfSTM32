# IAR project webserver-ssl-ek-lm3s6965_revc.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: LM3Sx9xx Luminary LM3Sx9xx
  ICCARM.CCDefines: ewarm; PART_LM3S6965; LUMINARY_MICRO
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: .; ..\..\..; ..\..\..\driverlib; ..\..\..\boards\ek-lm3s6965_revc; ..\..\..\boards\ek-lm3s6965_revc; ..\..\..\third_party\lwip-1.3.0\apps\httpserver_raw; ..\..\..\third_party\lwip-1.3.0\ports\stellaris\include; ..\..\..\third_party\lwip-1.3.0\src\include; ..\..\..\third_party\lwip-1.3.0\src\include\ipv4; ..\..\..\..\MatrixSSL\matrixssl-1-8-6-open; ..\..\..\third_party\fatfs\src; ..\..\..\utils
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  AARM.ADefines: ewarm
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: webserver-ssl-ek-lm3s6965_revc.bin
  ILINK.IlinkOutputFile: webserver-ssl-ek-lm3s6965_revc.out
  ILINK.IlinkIcfFile: webserver-ssl-ek-lm3s6965_revc.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Libraries
    ../../../driverlib/ewarm/Exe/: driverlib.a
  group Source
    ../../../../MatrixSSL/matrixssl-1-8-6-open/src/crypto/peersec/: arc4.c base64.c des3.c md2.c md5.c mpi.c rsa.c sha1.c
    ../../../../MatrixSSL/matrixssl-1-8-6-open/src/pki/: asn1.c rsaPki.c x509.c
    ../../../third_party/bget/: bget.c
    ./: certSrv.c display.c httpsd.c lmi_fs.c privkeySrv.c ssl.c startup_ewarm.c webserver-ssl.c
    ../../../../MatrixSSL/matrixssl-1-8-6-open/src/: cipherSuite.c matrixSsl.c sslDecode.c sslEncode.c sslv3.c
    ../../../../MatrixSSL/matrixssl-1-8-6-open/src/os/: debug.c
    ../../../third_party/fatfs/src/: ff.c
    ../../../utils/: lwiplib.c uartstdio.c ustdlib.c
    ../../../third_party/fatfs/port/: mmc-ek-lm3s6965.c
    ../../../../MatrixSSL/matrixssl-1-8-6-open/src/os/no_os/: no_os.c
    ../../../boards/ek-lm3s6965_revc/: rit128x96x4.c
