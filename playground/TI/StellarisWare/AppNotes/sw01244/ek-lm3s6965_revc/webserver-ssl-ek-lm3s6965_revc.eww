<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\webserver-ssl-ek-lm3s6965_revc.ewp</path>
  </project>
  <batchBuild/>
</workspace>
