<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\..\..\src\driverlib-ewarm4.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\ek-lm3s6965_revc\webserver-ssl-ek-lm3s6965_revc-ewarm4.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\ek-lm3s6965\webserver-ssl-ek-lm3s6965-ewarm4.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\ek-lm3s8962\webserver-ssl-ek-lm3s8962-ewarm4.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All Examples</name>
      <member>
        <project>driverlib-ewarm4</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>ek-lm3s6965_revc-ewarm4</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>ek-lm3s6965-ewarm4</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>ek-lm3s8962-ewarm4</project>
        <configuration>Debug</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
